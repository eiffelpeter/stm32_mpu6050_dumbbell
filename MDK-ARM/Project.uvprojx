# Keil uVision project Project.uvprojx, settings and files
target STM32F030R8-Nucleo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F030R8-Nucleo
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F030x8,USE_HAL_DRIVER,USE_STM32F0XX_NUCLEO
  c misc: --C99
  c include: ..\Inc;..\STM32CubeF0\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\STM32CubeF0\Drivers\STM32F0xx_HAL_Driver\Inc;..\STM32CubeF0\Drivers\BSP\STM32F0xx-Nucleo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Example/MDK-ARM
    ./: startup_stm32f030x8.s
  group Drivers/BSP/STM32F0xx-Nucleo
    ../STM32CubeF0/Drivers/BSP/STM32F0xx-Nucleo/: stm32f0xx_nucleo.c
  group Example/User
    ../Src/: stm32f0xx_it.c main.c stm32f0xx_hal_msp.c mpu6050.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../STM32CubeF0/Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_uart_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_cortex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_gpio.c
software components: CMSIS:CORE 4.1.0
